# Keil uVision project dose_v2.uvprojx, settings and files
target dose_v2 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dose_v2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\;D:\工程文件\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport;D:\工程文件\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;D:\工程文件\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc
  asm define: STM32F10X_MD
  asm include: ..\;D:\工程文件\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  group User
    ../: main.c dose.c keys.c alarm.c oled_ssd1306.c ble_softuart.c mca.c
  group CMSIS
    D:/工程文件/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    D:/工程文件/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph
    D:/工程文件/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c misc.c stm32f10x_adc.c stm32f10x_exti.c
  group Startup
    D:/工程文件/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
